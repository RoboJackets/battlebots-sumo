# Repository RoboJackets/battlebots-sumo

## EAGLE design Radio/Radii.brd

Parts:
C1, C2, C3, C6, C9, C10, C11, C15, C16, C17, C18, C19, C20: 0.1uF; 0603
C4: 1.0uF; 0603
C5: 10uF; 0603
C7, C8: 22uF; 1210
C12: 10nF; 0603
C13, C14: 33pF; 0603
D1, D2: GREEN; CHIP-LED0603
J1: 10118193-0001LF; FCI_10118193-0001LF
J2, J3, J4, J5, J6: BUTTON; 1X02
J7: S2B-PH-SM4-TB(LF)(SN); JST_S2B-PH-SM4-TB(LF)(SN)
JP1: PINHD-1X7; 1X07
JP2: PINHD-1X1; 1X01
Q1: PMOS; SOT-23-3
R1, R2: 22Ω; 0603-RES
R3, R4: 0603
R5, R6, R8, R10, R11, R13, R15, R17: 10K; 0603-RES
R7, R9, R12, R14, R16: 1K; 0603-RES
S1: KMR2
U1: RFM69HCW_SMT; RFMHCW_SMT
U2: ATMEGA32U4-AUR; 44-TQFP(10X10)
U3: AP63203WU-7; TSOT-23-6
U4: 3.9uH; 1255AY-3R9N=P3
Y1: 8.000 MHz; XTAL_ECS-80-20-5PX-TR

Connections:
3.3V: C1.1, C2.1, C3.1, C4.1, C7.1, C8.1, C9.1, C10.1, C11.1, D2.A, J2.1, J3.1, J4.1, J5.1, J6.1, JP1.1, R10.1, R11.2, R17.2, U1.5P (VDD), U2.6 (UCAP), U2.14 (VCC), U2.24 (AVCC), U2.34 (VCC), U2.44 (AVCC), U3.1 (FB), U4.2
9V: C5.1, D1.A, Q1.2 (S), U3.2 (EN), U3.3 (VIN)
BUTTON1: C17.1, R7.1, U2.20 (PD2(RXD1/INT2))
BUTTON2: C16.1, R12.1, U2.21 (PD3(TXD1/INT3))
BUTTON3: C19.1, R14.1, U2.25 (PD4(ICP1/ADC8))
BUTTON4: C18.1, R9.1, U2.22 (PD5(XCK1/!CTS!))
BUTTON5: C20.1, R16.1, U2.27 (PD7(T0/OC4D/ADC10))
CS: JP1.5, R17.1, U2.30 (PB6(PCINT6/OC1B/OC4B/ADC))
DC_SELECT: JP1.7, U2.28 (PB4(PCINT4/ADC11))
DIFF1_N: R1.2, U2.3 (D-)
DIFF1_P: R2.2, U2.4 (D+)
DIFF_N: J1.2 (D-), R1.1
DIFF_P: J1.3 (D+), R2.1
DISP_RESET: JP1.6, U2.29 (PB5(PCINT5/OC1A/OC4B/ADC))
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, J1.5 (GND), J1.S1 (SHIELD), J1.S2 (SHIELD), J1.S3 (SHIELD), J1.S4 (SHIELD), J1.S5 (SHIELD), J1.S6 (SHIELD), J7.2, J7.S1 (SHIELD), J7.S2 (SHIELD), JP1.2, Q1.1 (G), R3.2, R4.2, R5.1, R6.1, R8.1, R13.1, R15.1, S1.2.1 (2), S1.2.2 (2), U1.2P (GND), U1.9P (GND), U1.16P (GND), U2.5 (UGND), U2.15 (GND), U2.23 (GND), U2.35 (GND), U2.43 (GND), U3.4 (GND)
INT: U1.6P (DIO0), U2.36 (PF7(ADC7/TDI))
MISO: U1.10P (MISO), U2.11 (PB3(PDO/PCINT3/MISO))
MOSI: JP1.4, U1.11P (MOSI), U2.10 (PB2(PDI/PCINT2/MOSI))
unnamed: C6.2, U3.5 (SW), U4.1
unnamed: C6.1, U3.6 (BST)
unnamed: JP2.1, U1.1P (ANT)
unnamed: J3.2, R6.2, R7.2
unnamed: C13.1, U2.16 (XTAL2), Y1.2
unnamed: C12.1, U2.42 (AREF)
unnamed: C14.1, U2.17 (XTAL1), Y1.1
unnamed: D1.C (K), R3.1
unnamed: D2.C (K), R4.1
unnamed: J2.2, R5.2, R12.2
unnamed: J4.2, R8.2, R9.2
unnamed: J5.2, R13.2, R14.2
unnamed: J6.2, R15.2, R16.2
unnamed: C15.1, R10.2, S1.1.1 (1), S1.1.2 (1), U2.13 (!RESET)
RADIO_RESET: U1.14P (RESET), U2.37 (PF6(ADC6/TDO))
SCK: JP1.3, U1.12P (SCK), U2.9 (PB1(PCINT1/SCLK))
SS: R11.1, U1.13P (NSS), U2.38 (PF5(ADC5/TMS))
VCC: J7.1, Q1.3 (D)
VUSB: J1.1 (VUSB), U2.7 (VBUS)

Notes on the sheet:
Power
MCU Pinout
Radio Module
LCD Display
Radio Debugging Device for Sumo Bot
RoboWrestling
USB Connector
Buttons

Board: 2 copper layers, 42.6 x 44.9 mm, 57 parts (2 on the bottom side), 37 nets.

Other parts of the board:
U$1: ROBOBUZZ_0.8X
U$2: ROBOJACKETS

## EAGLE design PowerDistribution/powerDistribution.brd

Board: 2 copper layers, 79.8 x 81.8 mm, 54 parts (0 on the bottom side), 27 nets.

Parts:
+3.3V, +5V, +24V: Green; CHIP-LED0603
C1, C2, C5, C6: 0.1uF; C0603
C3, C4: 1000pF; C0603
C7, C10: 180uF; 860010373009
C8, C9: 4.7uF; C0603
C11, C13, C14: 15uF; TR3E156M050C0300
C12: 0.47uF; C0603
C15: 100nF; C0603
D1: SD2114S040S8R0
D2, D3: DFLS130L-7_30V_1A
D4: TVSDIODE
F1: 5A; ERB-RE5R00V
J1: XT-60BATT_LABEL; XT-60
J2, J3: ESC_CONNECT
J4: MOLEX_2.54MM_2PIN
J5: AMPHENOL_2X3_2.54MM
L1: 22uH; INDUCTOR22
R1, R2, R9, R13: 20k; R0603
R3, R10, R14: 100; R0603
R4: 200; R0603
R5: 1200; R0603
R6: 1k; R0603
R7, R8, R11, R12: 39k; R0603
U1: MAX11635EEE+; 21-0055H_16_MXM
U2: LM2678SX-5.0/NOPB; TS7B
U3, U4: CQ2065
U7: AP2114H-3.3TRG1; SOT-223
U$1: ROBOJACKETS
U$2: ROBOBUZZ_0.2X
U$4: ROBOBUZZ_0.4X
U$5: ROBOBUZZ_0.6X
XF1, XF2: 40A; 3550

Connections:
!CS!: J5.P$4, R6.1, U1.12
!EOC!: J5.P$2, U1.16
!START!: J5.P$3, U1.8
+3V3: C6.1, C9.1, D3.P$2, R3.2, R6.2, U1.11, U7.2, U7.4
+5V: C1.1, C2.1, C8.1, D2.P$2, D3.P$1, F1.P$2, J4.P$1, R4.2, R9.2, R13.2, U3.2, U4.2, U7.3
+24V: C11.1, C12.1, C13.1, C14.1, D2.P$1, D4.P$2, J1.BATT, R5.2, U2.2, XF1.3, XF1.4, XF2.1, XF2.2
GND: +3.3V.C, +5V.C, +24V.C, C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, D1.1, D4.P$1, J1.GND, J2.GND, J3.GND, J4.P$2, R7.1, R8.2, R11.1, R12.2, U1.3, U1.4, U1.7, U1.10, U2.4, U2.8, U3.1, U3.3, U3.5, U4.1, U4.3, U4.5, U7.1
I1: U3.6, XF1.1, XF1.2
I2: U4.7, XF2.3, XF2.4
L_ESC: J2.ESC, U3.7
L_MOTOR: C3.1, R10.1, U1.1
MISO: J5.P$1, U1.15
MOSI: J5.P$6, U1.14
unnamed: R1.1, U4.4
unnamed: R2.2, R7.2, R10.2
unnamed: R2.1, U3.4
unnamed: R1.2, R11.2, R14.2
unnamed: +3.3V.A, R3.1
unnamed: C15.2, D1.2, L1.P$1, U2.1
unnamed: C15.1, U2.3
unnamed: +5V.A, R4.1
unnamed: +24V.A, R5.1
unnamed: C7.1, C10.1, F1.P$1, L1.P$2, U2.6
R_ESC: J3.ESC, U4.6
R_MOTOR: C4.1, R14.1, U1.2
SCLK: J5.P$5, U1.13
VREF: C5.1, R8.1, R9.1, R12.1, R13.1, U1.9

## Commit log

2017-09-06 Chaged control file
2017-09-08 Bug fixes
2017-10-10 Create sumo_interrupts.ino
    added interrupt driven control
2017-10-20 changed jumper pins
2018-09-07 started new folder for v1 Gucci
2018-10-05 pushing some comments i guess
2018-10-18 fixed some things
2018-10-25 nothing breaks thank goodness
2019-01-12 post-comp files
2019-04-12 oh boy
2019-04-12 Hey this dodging control logic kinda works
2019-04-19 Gucci doesn't wanna perform
2019-04-19 starting to get it working
2019-12-10 Add data logging to Guccii
2019-12-10 Make it compile
2019-12-10 testing
2020-09-23 Radio board broken
2020-09-23 fixed issue
2020-09-24 started update on power dist lib

Notices in the files:
parts and their libraries:
SparkFun-Capacitors: Licensing: Creative Commons ShareAlike 4.0 International - https://creativecommons.org/licenses/by-sa/4.0
